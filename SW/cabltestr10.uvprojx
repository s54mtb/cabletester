# Keil uVision project cabltestr10.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F070F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: cabltestr10 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group CableTestrApp
    ./: main.c leds.c stm32f0xx_it.c stm32f0xx_hal_msp.c settings.c
software components: CMSIS:CORE 5.4.0, Device:STM32Cube HAL:COMMON 1.7.0, Device:STM32Cube HAL:CORTEX 1.7.0, Device:STM32Cube HAL:DMA 1.7.0, Device:STM32Cube HAL:FLASH 1.7.0, Device:STM32Cube HAL:GPIO 1.7.0, Device:STM32Cube HAL:RCC 1.7.0, Device:STM32Cube HAL:TIM 1.7.0, Device:Startup 1.0.0
